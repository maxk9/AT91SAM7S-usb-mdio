# Keil uVision project USb_MDIO.uvproj, settings and files
target USB_MDIO (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: AT91SAM7S256 Atmel
  cpu: IRAM(0x200000-0x20FFFF) IROM(0x100000-0x13FFFF) CLOCK(20000000) CPUTYPE(ARM7TDMI)
  output: USb_MDIO +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: at91sam7s256 NOFPUT NOASSERT
  c include: ..\USB_MDIO;.\at91lib\boards\at91sam7s-ek;.\main;.\at91lib\peripherals\aic;.\at91lib\peripherals\dbgu;.\at91lib\peripherals\pio;.\at91lib\peripherals\pit;.\at91lib\peripherals\pmc;.\at91lib\peripherals\tc;.\at91lib\peripherals\usart;.\at91lib\usb\common\cdc;.\at91lib\usb\common\core;.\at91lib\usb\device\cdc-serial;.\at91lib\usb\device\core;.\at91lib\utility;.\mdio;.\at91lib\peripherals\pwmc;.\at91lib\peripherals\spi
  memory RVCT4: ROM 0x100000 size 0x40000
  memory RVCT9: RAM 0x200000 size 0x10000
  group startup
    ./: SAM7.s
  group main
    ./: README.txt
    ./main/: main.c lcd_siem_s65.c consol.c microrl.c
  group lib
    ./at91lib/peripherals/aic/: aic.c
    ./at91lib/peripherals/dbgu/: dbgu.c
    ./at91lib/peripherals/pio/: pio.c pio_it.c
    ./at91lib/peripherals/pit/: pit.c
    ./at91lib/peripherals/pmc/: pmc.c
    ./at91lib/peripherals/tc/: tc.c
    ./at91lib/utility/: led.c retarget.c
    ./at91lib/boards/at91sam7s-ek/: board_lowlevel.c board_memories.c
    ./at91lib/peripherals/pwmc/: pwmc.c
    ./at91lib/peripherals/spi/: spid.c
  group usb
    ./at91lib/usb/common/core/: USBConfigurationDescriptor.c USBEndpointDescriptor.c USBFeatureRequest.c USBGenericDescriptor.c USBGenericRequest.c USBGetDescriptorRequest.c USBInterfaceRequest.c USBSetAddressRequest.c USBSetConfigurationRequest.c
    ./at91lib/usb/device/core/: USBD_OTGHS.c USBD_UDP.c USBD_UDPHS.c USBDCallbacks_Initialized.c USBDCallbacks_Reset.c USBDDriver.c USBDDriverCb_CfgChanged.c USBDDriverCb_IfSettingChanged.c
    ./at91lib/usb/common/cdc/: CDCLineCoding.c CDCSetControlLineStateRequest.c
    ./at91lib/usb/device/cdc-serial/: CDCDSerialDriver.c CDCDSerialDriverDescriptors.c
  group mdio
    ./mdio/: mdio_drv.c
